# KOMPAS-3D part (çáú½πΦ¬á ¬«α»πßá rev.C.m3d)

Model tree:
1. Эскиз:1
2. Листовое тело:2
     Расстояние 1 = 10; Расстояние 2 = 10

Texts:
  Im2